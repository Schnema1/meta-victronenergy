DESCRIPTION = "Generic Victron image"

require venus-image.inc

# Note: The Venus GX was shipped with this partion size initially.
IMAGE_ROOTFS_PARTITION_SIZE_beaglebone = "327680"
