require venus-swu.inc

IMAGE_BASENAME = "venus-swu-large"
VENUS_IMAGE = "venus-image-large"
